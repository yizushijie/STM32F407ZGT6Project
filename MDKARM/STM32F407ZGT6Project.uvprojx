# Keil uVision project STM32F407ZGT6Project.uvprojx, settings and files
target STM32F407ZGT6Project (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F407ZGT6Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,USE_FULL_GPIO,HSE_VALUE=8000000UL,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,STM32F407xx,__TARGET_FPU_VFP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__FPU_PRESENT=1
  c misc: -fgnu
  c include: ..\Complier;..\Doc;..\DriversEx\Complier;..\DriversEx\STM32F4xx;..\STARTUP\MDKARM;..\Drivers\CMSIS\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Src;..\Application\APP;..\Application\IWDG;..\Application\AD5593;..\Application\AT24Cxx;..\Application\CRC;..\Application\Delay;..\Application\DHT11;..\Application\DS18B20;..\Application\GPIO;..\Application\I2C;..\Application\OneWire;..\Application\PCF8563;..\Application\Random;..\Application\SysTick;..\Application\UART;..\Application\WM8510;..\Application\HMC830;..\Application\ISP;..\Application\SPI;..\Application\LED;..\Application\ADC;..\Application\Timer;..\Application\Key;..\Application\Power;..\Application\EEPROM;..\Application\RFASK;..\Application\FLASH;..\Application\NRF2401;..\Application\LCD1602;..\Application\BKP;..\Application\SHT2x;..\Application\Decode;..\Application\CSS;..\Application\ADS868x;..\Application\IAP;..\Application\OLED;..\Application\WWDG;..\Application\W25Qxx;..\Application\RFASKHW;..\Application\DS1302;..\Application\ENC28J60;..\Application\PID;..\Application\ADS1256;..\Application\RTC;..\Application\PVD;..\Application\MyMalloc;..\Application\ADS869x;..\Application\DAC;..\Application\KalmanFilter;..\Application\SDIO;..\Application\W5500;..\Application\MAX961x;..\Application\SMBUS;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Application\LIN;..\Application\HMC5883;..\Application\INA226;..\Application\SI5351A;..\Application\TaskManage;..\Application\JTAG;..\Application\HVPP;..\Application\HVSP;..\Application\AHT10;..\Application\HMC472;..\Application\Encode;..\Application\EXTI;..\Application\HardWare;..\Application\MCO;..\Application\USB\USBHid;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;..\Application\USB\USB;..\Application\ESP8266;..\Application\FIFO;..\Application\DataBus;..\Application\cJSON;..\Application\AES;..\Application\CAN;..\Application\BMP180;..\Application\MPU6050;..\Application\DMP;..\Application\DMA;..\Application\LMS;..\DriversEx\CMSIS\STM32F4;..\DebugLog
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Complier
    ../Complier/: complier_cfg.c complier_cfg.h complier_lib.c complier_lib.h
  group Doc
    ../Doc/: ReadMe.txt
  group DriversEx/Complier
    ../DriversEx/Complier/: stm32_cfg.c stm32_cfg.h
  group DriversEx/STM32F4xx
    ../DriversEx/STM32F4xx/: stm32_assert.h stm32f4xx.h stm32f4xx_hal_conf.h stm32f4xx_it.c stm32f4xx_it.h stm32f4xx_ll.h stm32f407xx.h
  group Drivers/CMSIS
    ../DriversEx/CMSIS/STM32F4/: system_stm32f4xx.c system_stm32f4xx.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_pwr.c stm32f4xx_ll_dac.c stm32f4xx_ll_i2c.c
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_gpio.h stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_dac.h stm32f4xx_ll_exti.h stm32f4xx_ll_gpio.h stm32f4xx_ll_rcc.h stm32f4xx_ll_rng.h stm32f4xx_ll_rtc.h stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_usart.h stm32f4xx_ll_utils.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.h stm32f4xx_ll_wwdg.h stm32f4xx_ll_pwr.h stm32f4xx_ll_i2c.h
  group STARTUP/MDKARM
    ../STARTUP/MDKARM/STM32F4/: startup_stm32f407xx.s
  group Application/AD5593
    ../Application/AD5593/: ad5593_cfg.c ad5593_cfg.h ad5593_lib.c ad5593_lib.h ad5593_task.c ad5593_task.h
  group Application/ADC
    ../Application/ADC/: adc_cfg.c adc_cfg.h adc_lib.c adc_lib.h adc_task.c adc_task.h
  group Application/ADS1256
    ../Application/ADS1256/: ads1256_cfg.c ads1256_cfg.h ads1256_lib.c ads1256_lib.h ads1256_task.c ads1256_task.h
  group Application/ADS868x
    ../Application/ADS868x/: ads868x_cfg.c ads868x_cfg.h ads868x_lib.c ads868x_lib.h ads868x_task.c ads868x_task.h
  group Application/ADS869x
    ../Application/ADS869x/: ads869x_cfg.c ads869x_cfg.h ads869x_lib.c ads869x_lib.h ads869x_task.c ads869x_task.h
  group Application/APP
    ../Application/APP/: main.c main.h config.h
  group Application/AT24Cxx
    ../Application/AT24Cxx/: at24cxx_cfg.c at24cxx_cfg.h at24cxx_lib.c at24cxx_lib.h at24cxx_task.c at24cxx_task.h
  group Application/BKP
    ../Application/BKP/: bkp_cfg.c bkp_cfg.h bkp_lib.c bkp_lib.h bkp_task.c bkp_task.h
  group Application/CRC
    ../Application/CRC/: crc_cfg.c crc_cfg.h crc_lib.c crc_lib.h crc_task.c crc_task.h
  group Application/CSS
    ../Application/CSS/: css_cfg.c css_cfg.h css_lib.c css_lib.h css_task.c css_task.h
  group Application/DAC
    ../Application/DAC/: dac_cfg.c dac_cfg.h dac_lib.c dac_lib.h dac_task.c dac_task.h
  group Application/Decode
    ../Application/Decode/: decode_lib.c decode_lib.h decode_task.c decode_task.h decode_cfg.c decode_cfg.h
  group Application/Delay
    ../Application/Delay/: delay_cfg.c delay_cfg.h delay_lib.c delay_lib.h delay_task.c delay_task.h
  group Application/DHT11
    ../Application/DHT11/: dht11_cfg.c dht11_cfg.h dht11_lib.c dht11_lib.h dht11_task.c dht11_task.h
  group Application/DS1302
    ../Application/DS1302/: ds1302_cfg.c ds1302_cfg.h ds1302_lib.c ds1302_lib.h ds1302_task.c ds1302_task.h
  group Application/DS18B20
    ../Application/DS18B20/: ds18b20_cfg.c ds18b20_cfg.h ds18b20_lib.c ds18b20_lib.h ds18b20_task.c ds18b20_task.h
  group Application/EERPOM
    ../Application/EEPROM/: eeprom_cfg.c eeprom_cfg.h eeprom_lib.c eeprom_lib.h eeprom_task.c eeprom_task.h
  group Application/ENC28J60
    ../Application/ENC28J60/: enc28j60_cfg.c enc28j60_cfg.h enc28j60_lib.c enc28j60_lib.h enc28j60_task.c enc28j60_task.h
  group Application/FLASH
    ../Application/FLASH/: flash_cfg.c flash_cfg.h flash_lib.c flash_lib.h flash_task.c flash_task.h
  group Application/GPIO
    ../Application/GPIO/: gpio_cfg.c gpio_cfg.h gpio_lib.c gpio_lib.h gpio_task.c gpio_task.h
  group Application/HMC830
    ../Application/HMC830/: hmc830_cfg.c hmc830_cfg.h hmc830_lib.c hmc830_lib.h hmc830_task.c hmc830_task.h
  group Application/I2C
    ../Application/I2C/: i2c_cfg.c i2c_cfg.h i2c_lib.c i2c_lib.h i2c_task.c i2c_task.h
  group Application/IAP
    ../Application/IAP/: iap_cfg.c iap_cfg.h iap_lib.c iap_lib.h iap_task.c iap_task.h
  group Application/ISP
    ../Application/ISP/: isp_cfg.c isp_cfg.h isp_lib.c isp_lib.h isp_task.c isp_task.h
  group Application/IWDG
    ../Application/IWDG/: iwdg_cfg.c iwdg_cfg.h iwdg_lib.c iwdg_lib.h iwdg_task.c iwdg_task.h
  group Application/KalmanFilter
    ../Application/KalmanFilter/: kalman_filter.c kalman_filter.h
  group Application/Key
    ../Application/Key/: key_cfg.c key_cfg.h key_lib.c key_lib.h key_task.c key_task.h
  group Application/LCD1602
    ../Application/LCD1602/: lcd1602_cfg.c lcd1602_cfg.h lcd1602_lib.c lcd1602_lib.h lcd1602_task.c lcd1602_task.h
  group Application/LED
    ../Application/LED/: led_cfg.c led_cfg.h led_lib.c led_lib.h led_task.c led_task.h
  group Application/MyMalloc
    ../Application/MyMalloc/: my_malloc.c my_malloc.h
  group Application/NRF2401
    ../Application/NRF2401/: nrf2401_cfg.c nrf2401_cfg.h nrf2401_lib.c nrf2401_lib.h nrf2401_task.c nrf2401_task.h
  group Application/OLED
    ../Application/OLED/: oled_cfg.c oled_cfg.h oled_lib.c oled_lib.h oled_task.c oled_task.h
  group Application/OneWire
    ../Application/OneWire/: one_wire_cfg.c one_wire_cfg.h one_wire_lib.c one_wire_lib.h one_wire_task.c one_wire_task.h
  group Application/PCF8563
    ../Application/PCF8563/: pcf8563_cfg.c pcf8563_cfg.h pcf8563_lib.c pcf8563_lib.h pcf8563_task.c pcf8563_task.h
  group Application/PID
    ../Application/PID/: pid_cfg.c pid_cfg.h pid_lib.c pid_lib.h pid_task.c pid_task.h
  group Application/Power
    ../Application/Power/: power_cfg.c power_cfg.h power_lib.c power_lib.h power_task.c power_task.h
  group Application/PVD
    ../Application/PVD/: pvd_cfg.c pvd_cfg.h pvd_lib.c pvd_lib.h pvd_task.c pvd_task.h
  group Application/Random
    ../Application/Random/: random_cfg.c random_cfg.h random_lib.c random_lib.h random_task.c random_task.h
  group Application/RFASK
    ../Application/RFASK/: rfask_cfg.c rfask_cfg.h rfask_lib.c rfask_lib.h rfask_task.c rfask_task.h rfask_eeprom.c rfask_eeprom.h
  group Application/RFASKHW
    ../Application/RFASKHW/: rfaskhw_cfg.c rfaskhw_cfg.h
  group Application/RTC
    ../Application/RTC/: rtc_cfg.c rtc_cfg.h rtc_lib.c rtc_lib.h rtc_task.c rtc_task.h
  group Application/SHT2x
    ../Application/SHT2x/: sht2x_cfg.c sht2x_cfg.h sht2x_lib.c sht2x_lib.h sht2x_task.c sht2x_task.h
  group Application/SPI
    ../Application/SPI/: spi_cfg.c spi_cfg.h spi_lib.c spi_lib.h spi_task.c spi_task.h
  group Application/SysTick
    ../Application/SysTick/: systick_cfg.c systick_cfg.h systick_lib.c systick_lib.h systick_task.c systick_task.h
  group Application/Timer
    ../Application/Timer/: timer_cfg.c timer_cfg.h timer_lib.c timer_lib.h timer_task.c timer_task.h
  group Application/UART
    ../Application/UART/: uart_cfg.c uart_cfg.h uart_lib.c uart_lib.h uart_task.c uart_task.h
  group Application/W25Qxx
    ../Application/W25Qxx/: w25qxx_cfg.c w25qxx_cfg.h w25qxx_lib.c w25qxx_lib.h w25qxx_task.c w25qxx_task.h
  group Application/WM8510
    ../Application/WM8510/: wm8510_cfg.c wm8510_cfg.h wm8510_lib.c wm8510_lib.h wm8510_task.c wm8510_task.h
  group Application/WWDG
    ../Application/WWDG/: wwdg_cfg.c wwdg_cfg.h wwdg_lib.c wwdg_lib.h wwdg_task.c wwdg_task.h
  group Application/ModBusSlave
    ../Application/ModBusSlave/: mobus_slave_cfg.c mobus_slave_cfg.h mobus_slave_lib.c mobus_slave_lib.h mobus_slave_task.c mobus_slave_task.h
  group Application/ModBusMaster
    ../Application/ModBusMaster/: modbus_master_cfg.c modbus_master_cfg.h modbus_master_lib.c modbus_master_lib.h modbus_master_task.c modbus_master_task.h
  group Application/SDIO
    ../Application/SDIO/: sdio_cfg.c sdio_cfg.h sdio_lib.c sdio_lib.h sdio_task.c sdio_task.h
  group Application/W5500
    ../Application/W5500/: w5500_cfg.c w5500_cfg.h w5500_lib.c w5500_lib.h w5500_task.c w5500_task.h
  group Application/Encode
    ../Application/Encode/: encode_cfg.c encode_cfg.h encode_lib.c encode_lib.h encode_task.c encode_task.h
  group Application/MAX961x
    ../Application/MAX961x/: max961x_cfg.c max961x_cfg.h max961x_lib.c max961x_lib.h max961x_task.c max961x_task.h
  group Application/SMBUS
    ../Application/SMBUS/: smbus_cfg.c smbus_cfg.h smbus_lib.c smbus_lib.h smbus_task.c smbus_task.h
  group Application/LIN
    ../Application/LIN/: lin_cfg.c lin_cfg.h lin_lib.c lin_lib.h lin_task.c lin_task.h
  group Application/HMC5883
    ../Application/HMC5883/: hmc5883_cfg.c hmc5883_cfg.h hmc5883_lib.c hmc5883_lib.h hmc5883_task.c hmc5883_task.h
  group Application/INA226
    ../Application/INA226/: ina226_cfg.c ina226_cfg.h ina226_lib.c ina226_lib.h ina226_task.c ina226_task.h
  group Application/SI5351A
    ../Application/SI5351A/: si5351a_cfg.c si5351a_cfg.h si5351a_lib.c si5351a_lib.h si5351a_task.c si5351a_task.h
  group Application/TaskManage
    ../Application/TaskManage/: task_manage.c task_manage.h
  group Application/JTAG
    ../Application/JTAG/: jtag_cfg.c jtag_cfg.h jtag_lib.c jtag_lib.h jtag_task.c jtag_task.h
  group Application/HVPP
    ../Application/HVPP/: hvpp_cfg.c hvpp_cfg.h hvpp_lib.c hvpp_lib.h hvpp_task.c hvpp_task.h
  group Application/HVSP
    ../Application/HVSP/: hvsp_cfg.c hvsp_cfg.h hvsp_lib.c hvsp_lib.h hvsp_task.c hvsp_task.h
  group Application/AHT10
    ../Application/AHT10/: aht10_cfg.c aht10_cfg.h aht10_lib.c aht10_lib.h aht10_task.c aht10_task.h
  group Application/HMC472
    ../Application/HMC472/: hmc472_cfg.c hmc472_cfg.h hmc472_lib.c hmc472_lib.h hmc472_task.c hmc472_task.h
  group Application/EXTI
    ../Application/EXTI/: exti_cfg.c exti_cfg.h exti_lib.c exti_lib.h exti_task.c exti_task.h
  group Application/HardWare
    ../Application/HardWare/: hw_cfg.c hw_cfg.h
  group Application/MCO
    ../Application/MCO/: mco_cfg.c mco_cfg.h
  group Application/USB/USBHid
    ../Application/USB/USBHid/: usbhid_cfg.c usbhid_cfg.h usbhid_lib.c usbhid_lib.h usbhid_task.c usbhid_task.h
  group Application/USB/USB
    ../Application/USB/USB/: usb_cfg.c usb_cfg.h usb_lib.c usb_lib.h usb_task.c usb_task.h
  group Application/ESP8266
    ../Application/ESP8266/: esp8266_cfg.c esp8266_cfg.h esp8266_lib.c esp8266_lib.h esp8266_task.c esp8266_task.h
  group Application/FIFO
    ../Application/FIFO/: fifo.c fifo.h queue_fifo.c queue_fifo.h
  group Application/DataBus
    ../Application/DataBus/: data_bus.c data_bus.h
  group Application/cJSON
    ../Application/cJSON/: cJSON.c cJSON.h
  group Application/AES
    ../Application/AES/: aes_cfg.c aes_cfg.h aes_lib.c aes_lib.h aes_task.c aes_task.h
  group Application/CAN
    ../Application/CAN/: can_cfg.c can_cfg.h can_lib.c can_lib.h can_task.c can_task.h
  group Application/MPU6050
    ../Application/MPU6050/: mpu6050_cfg.c mpu6050_cfg.h mpu6050_lib.c mpu6050_lib.h mpu6050_task.c mpu6050_task.h
  group Application/BMP180
    ../Application/BMP180/: bmp180_cfg.c bmp180_cfg.h bmp180_lib.c bmp180_lib.h bmp180_task.c bmp180_task.h
  group Application/NTC
    ../Application/NTC/: ntc_cfg.c ntc_cfg.h ntc_lib.c ntc_lib.h ntc_task.c ntc_task.h
  group Application/DMA
    ../Application/DMA/: dma_cfg.c dma_cfg.h dma_lib.c dma_lib.h dma_task.c dma_task.h
  group Application/LMS
    ../Application/LMS/: lms_filter.c lms_filter.h
  group DebugLog
    ../DebugLog/: log_cfg.c log_cfg.h
software components: CMSIS:CORE 5.3.0
